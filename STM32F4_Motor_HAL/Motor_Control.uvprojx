# Keil uVision project Motor_Control.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Motor_Control
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\APP\Ins;.\BSP\Ins;.\CONFIG;.\CORE\Inc;.\DRIVER\Ins;.\INTERFACE\Ins;.\UTILS\Ins;.\README;.\CORE\Ins;.\DRIVERS\CMSIS\Include;.\DRIVERS\CMSIS\Device\ST\STM32F4xx\Include;.\DRIVERS\STM32F4xx_HAL_Driver\Inc;.\DRIVERS\STM32F4xx_HAL_Driver\Inc\Legacy;.\PROTOCOL\Ins;.\ALGORITHM\Ins
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group AIGORITHM
    ./ALGORITHM/Src/: alg_pid.c
  group APP
    ./APP/Src/: main.c app_motor.c app_uart.c app_encoder.c
  group BSP
    ./BSP/Src/: bsp_motor.c bsp_uart.c bsp_encoder.c
  group CONFIG
    ./CONFIG/: gpio_config.h
  group DRIVER
    ./DRIVER/Src/: drv_pwm.c
  group INTERFACE
    ./INTERFACE/Src/: if_motor.c
  group README
    ./README/: readme.txt
  group CORE
    ./CORE/Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c startup_stm32f407xx.s
  group DRIVERS
    ./DRIVERS/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim_ex.c
  group PROTOCOL
    ./PROTOCOL/Src/: pt_uart.c
