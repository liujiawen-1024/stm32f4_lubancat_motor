# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\DRIVERS\CMSIS\Include;.\DRIVERS\STM32F4xx_HAL_Driver\Inc;.\DRIVERS\STM32F4xx_HAL_Driver\Inc\Legacy;.\USER;.\README;.\HARDWARE;.\DRIVERS\CMSIS\Device\ST\STM32F4xx\Include;.\HARDWARE\encoder;.\HARDWARE\key;.\HARDWARE\led;.\HARDWARE\motot;.\HARDWARE\usart;.\APP;.\HARDWARE\pid;.\HARDWARE\speed_control
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c startup_stm32f407xx.s
  group DRIVERS
    ./DRIVERS/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma_ex.c
  group README
    ./README/: readme.txt
  group HARDWARE
    ./HARDWARE/encoder/: encoder.c
    ./HARDWARE/key/: key.c
    ./HARDWARE/led/: led.c
    ./HARDWARE/motot/: motor.c
    ./HARDWARE/usart/: usart.c
    ./HARDWARE/pid/: pid.c
    ./HARDWARE/speed_control/: speed_control.c
  group APP
    ./APP/: app.c app_motor.c
